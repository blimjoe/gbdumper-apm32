# Keil uVision project project.uvprojx, settings and files
target APM32F103 (6190000::V6.19::ARMCLANG)
  device: APM32F103ZE Geehy
  pack: Geehy.APM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gbdumper +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: APM32F10X_HD,APM32F103_MINI
  c include: .\Application\Include;.\Boards;.\Libraries\APM32F10x_StdPeriphDriver\inc;.\Libraries\CMSIS\Include;.\Libraries\Device\Geehy\APM32F10x\Include;.\Libraries\USB_Device_Lib\Core_Device\Class\CDC\inc;.\Libraries\USB_Device_Lib\Core_Device\Standard\inc;.\Libraries\USB_Device_Lib\Driver\inc;.\RTT;.\Boards\Board_APM32F103_MINI\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ./Application/Source/: main.c apm32f10x_int.c func.c emuDump.c
    ./Application/Include/: func.h pin_out.h
  group APP/CDC
    ./Application/Source/: usbd_cdc.c usbd_descriptor.c usb_bsp.c
    ./Libraries/USB_Device_Lib/Core_Device/Class/CDC/src/: usbd_class_cdc.c
  group USB_Protocol
    ./Libraries/USB_Device_Lib/Core_Device/Standard/src/: usbd_init.c usbd_core.c usbd_interrupt.c usbd_stdReq.c
  group USB_Driver
    ./Libraries/USB_Device_Lib/Driver/src/: drv_usb_device.c
  group Board
    ./Boards/: Board.c
  group StdPeriphDriver
    ./Libraries/APM32F10x_StdPeriphDriver/src/: apm32f10x_adc.c apm32f10x_bakpr.c apm32f10x_crc.c apm32f10x_dac.c apm32f10x_dbgmcu.c apm32f10x_dmc.c apm32f10x_eint.c apm32f10x_smc.c apm32f10x_fmc.c apm32f10x_gpio.c apm32f10x_misc.c apm32f10x_rcm.c apm32f10x_rtc.c apm32f10x_wwdt.c
  group CMSIS
    ./Application/Source/: system_apm32f10x.c
    ./Libraries/Device/Geehy/APM32F10x/Source/arm/: startup_apm32f10x_hd.s startup_apm32f10x_md.s
  group RTT
    ./RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
